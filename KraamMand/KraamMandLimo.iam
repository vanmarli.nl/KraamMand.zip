# Autodesk Inventor assembly: KraamMandLimo
## iProperties
Created: 2010-03
Part Number: KraamMandLimo
Document SubType Name: Assembly
Designer: Ferry
Author: Ferry
